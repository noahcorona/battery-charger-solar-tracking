# Keil uVision project solar_tracker.uvprojx, settings and files
target stm32 (6150000::V6.15::ARMCLANG)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: solar_tracker +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group src
    ./src/: startup_stm32l476xx.s SysClock.c PWM.c I2C.c sensors.c main.c
  group include
    ./include/: stm32l476xx.h SysClock.h PWM.h I2C.h sensors.h
software components: CMSIS:CORE 5.4.0
